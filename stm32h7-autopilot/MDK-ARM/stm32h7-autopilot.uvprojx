# Keil uVision project stm32h7-autopilot.uvprojx, settings and files
target stm32h7-autopilot (ARM-ADS)
  device: STM32H743VITx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: stm32h7-autopilot
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include
  asm include: ..//Inc
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
    ../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
  group Drivers/CMSIS
    ..//Src/: system_stm32h7xx.c
  group Application/User
    ../Src/: usbd_conf.c freertos.c sd_diskio.c usb_device.c usbd_cdc_if.c stm32h7xx_it.c bsp_driver_sd.c main.c stm32h7xx_hal_timebase_TIM.c usbd_desc.c fatfs.c stm32h7xx_hal_msp.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c timers.c croutine.c queue.c event_groups.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_iwdg.c stm32h7xx_hal_rng.c stm32h7xx_hal_hsem.c stm32h7xx_hal_tim.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_flash.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_crc.c stm32h7xx_hal.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc.c stm32h7xx_hal_sd.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_uart.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_spi_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_pcd.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_cortex.c
software components: CMSIS:CORE 4.3.0
